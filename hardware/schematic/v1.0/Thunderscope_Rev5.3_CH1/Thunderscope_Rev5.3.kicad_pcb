# Repository Han-ZenX/SIG_COND

File README.md:

# SIG_COND - 高精度频率计前端双通道信号调理电路模块

## 项目概述

SIG_COND 是一款专为高精度频率计设计的前端双通道信号调理电路模块，提供卓越的信号采集和处理能力。该模块支持灵活的阻抗切换和 AC/DC 耦合切换，能够处理从微伏级到大幅度的宽范围信号，并配备标准的 SPI 和 I2C 双接口通信方式。

### 核心特性

- ✅ **双通道独立信号调理** - 两个完全独立的信号通道，可同时采集两路信号
- ✅ **阻抗自动/手动切换** - 支持高阻抗和低阻抗模式的灵活切换，适配不同信号源
- ✅ **AC/DC 耦合切换** - 支持交流耦合和直流耦合模式切换，适应多种应用场景
- ✅ **宽动态范围** - 从小幅度微弱信号到大幅度强信号，全覆盖处理
- ✅ **双接口通信** - 同时支持 SPI 和 I2C 接口，灵活选择通信方式
- ✅ **高精度信号采集** - 低噪声、低失真设计，确保测量精度
- ✅ **模块化设计** - 分层架构，易于集成和扩展

## 目录结构

```
SIG_COND-master/
├── firmware/          # 固件代码（MCU 控制程序）
│   ├── boards/        # 板级配置文件
│   ├── include/       # 头文件
│   ├── lib/           # 第三方库
│   ├── src/           # 源代码
│   │   ├── app/       # 应用层业务逻辑
│   │   ├── drivers/   # 外设驱动（SPI/I2C 等）
│   │   ├── hal/       # 硬件抽象层
│   │   └── services/  # 服务层（通信、配置管理等）
│   └── tests/         # 单元测试
│
├── hardware/          # 硬件设计文件
│   ├── schematic/     # 原理图
│   ├── pcb/           # PCB 布局文件
│   ├── bom/           # 物料清单
│   ├── gerber/        # 生产 Gerber 文件
│   ├── 3d/            # 3D 结构模型
│   └── pinout/        # 引脚定义
│
├── software/          # 配套软件
│   ├── desktop/       # PC 桌面应用
│   ├── mobile/        # 移动应用
│   └── cloud/         # 云端服务
│
├── docs/              # 技术文档
│   ├── architecture/  # 架构设计文档
│   ├── api/           # API 接口文档
│   ├── hardware/      # 硬件说明
│   └── user-guide/    # 用户手册
│
├── tests/             # 系统测试
│   ├── unit/          # 单元测试
│   ├── integration/   # 集成测试
│   └── hwt/           # 硬件在环测试
│
├── tools/             # 工具链
│   ├── scripts/       # 构建脚本
│   └── utilities/     # 辅助工具
│
└── ci/                # CI/CD 流水线配置
```

## 硬件规格

### 通道特性

| 参数 | 指标 |
|------|------|
| 通道数 | 2 路独立通道 |
| 输入阻抗 | 可编程切换（高阻/低阻） |
| 耦合方式 | AC/DC 可选 |
| 输入范围 | 微伏级～大幅度信号 |
| 信噪比 | 高信噪比设计 |
| 带宽 | 宽频带响应 |

### 接口规范

#### SPI 接口
- 时钟频率：最高可达 XX MHz
- 模式：支持 Mode 0/1/2/3
- 数据位：8/16/32 位可选
- 引脚定义：见 `hardware/pinout/pinout.md`

#### I2C 接口
- 速率：标准模式 (100kHz)、快速模式 (400kHz)、高速模式 (3.4MHz)
- 地址：可配置 I2C 地址
- 支持多主机和从机模式

## 软件架构

本项目采用**分层模块化架构**，核心设计原则：

- **更换 MCU 只改 HAL 层，业务逻辑零修改**
- **各层解耦，独立编译和测试**
- **支持多板级并行开发**

### 层次结构

```
┌─────────────────┐
│     App Layer   │  ← 业务逻辑、状态机、用户交互
├─────────────────┤
│  Services Layer │  ← 通信协议、配置管理、数据存储
├─────────────────┤
│   Drivers Layer │  ← SPI/I2C 驱动、外设控制
├─────────────────┤
│     HAL Layer   │  ← GPIO、时钟、中断抽象
└─────────────────┘
```

## 快速开始

### 环境要求

- CMake 3.16+
- ARM GCC 工具链 (10-bit-32bit)
- Python 3.8+ (用于构建脚本)
- Git + Git LFS (大文件支持)

### 构建固件

```bash
# 克隆仓库
git clone --recurse-submodules https://github.com/your-repo/SIG_COND.git
cd SIG_COND

# Debug 版本构建
cmake -B firmware/build -DBOARD=default
cmake --build firmware/build

# Release 版本构建
cmake -B firmware/build -DBOARD=default -DCMAKE_BUILD_TYPE=Release
cmake --build firmware/build --config Release

# 使用构建脚本（推荐）
python tools/scripts/build.py --board=default
python tools/scripts/build.py --board=default --release
```

### 烧录固件

```bash
# 烧录到目标板
python tools/scripts/build.py --flash
```

## 使用说明

### 初始化配置

1. **接口选择**：通过软件配置选择 SPI 或 I2C 通信接口
2. **阻抗设置**：配置通道输入阻抗模式（高阻/低阻）
3. **耦合方式**：选择 AC 或 DC 耦合
4. **增益设置**：根据信号幅度调整放大倍数

### 典型应用场景

- 🔬 实验室精密测量
- 📡 通信信号分析
- ⚡ 电力电子监测
- 🎵 音频信号测试
- 🏭 工业过程控制

## 开发指南

### 新增功能

```bash
# 创建功能分支
git checkout -b feat/new-feature

# 开发完成后
git add .
git commit -m "feat: 添加新功能"
git push origin feat/new-feature
```

### 硬件改版

当需要修改硬件设计时：

```bash
# 1. 更新原理图和 PCB（在 EDA 工具中）
# 2. 更新引脚定义
cp -r hardware/schematic/v1.0 hardware/schematic/v2.0

# 3. 更新固件板级配置
cp -r firmware/boards/default firmware/boards/v2.0

# 4. 编译验证
cmake -B firmware/build -DBOARD=v2.0
```

## 测试

```bash
# 运行单元测试
python tools/scripts/build.py --test=unit

# 运行集成测试
python tools/scripts/build.py --test=integration

# 完整测试套件
python tools/scripts/build.py --test=all
```

## 版本历史

### v1.0.0 (2026-08-04)
- ✨ 初始版本发布
- ✅ 实现双通道信号调理
- ✅ 完成阻抗切换功能
- ✅ 完成 AC/DC 切换功能
- ✅ 支持 SPI 和 I2C 接口
- ✅ 实现宽范围信号处理能力

## 技术支持

如需技术支持或遇到问题，请：

1. 查阅 [用户手册](docs/user-guide/)
2. 查看 [API 文档](docs/api/)
3. 提交 [GitHub Issue](https://github.com/your-repo/SIG_COND/issues)

## 贡献指南

欢迎贡献代码！请阅读 [贡献指南](CONTRIBUTING.md) 后提交 PR。

## 许可证

本项目采用 MIT 许可证。详见 [LICENSE](LICENSE) 文件。

---

**注意**：本产品仅供教育和专业用途，使用前请确保安全操作规范。

## KiCad design hardware/schematic/v1.0/Thunderscope_Rev5.3_CH1/Thunderscope_Rev5.3.kicad_pcb

Parts:
J1, J2: Conn_01x03_Socket; PinHeader_1x03_P2.54mm_Vertical
J3: Conn_02x06_Odd_Even; PinSocket_2x06_P1.27mm_Horizontal
RF1, RF2, RF3, RF4: KH-IPEX-K501-29; Manufacturer Part KH-IPEX-K501-29; LCSC C411563

Connections:
+3V3_PGA: J3.9; also elsewhere on the board
+5V: J3.3, J3.5; also elsewhere on the board
+VBIAS: J3.11; also elsewhere on the board
+VUSB: J3.1; also elsewhere on the board
-5V: J3.7; also elsewhere on the board
-VBIAS: J3.12; also elsewhere on the board
/ATTEN_1: J1.2; also elsewhere on the board
/CH1_AUX_N: RF4.4 (SIG); also elsewhere on the board
/CH1_AUX_P: RF3.4 (SIG); also elsewhere on the board
/CH1_N: RF2.4 (SIG); also elsewhere on the board
/CH1_P: RF1.4 (SIG); also elsewhere on the board
/DC_CPL_1: J1.3; also elsewhere on the board
/PGA_CSn_1: J2.1; also elsewhere on the board
/PGA_SCLK: J2.3; also elsewhere on the board
/PGA_SDIO: J2.2; also elsewhere on the board
/TERM_1: J1.1; also elsewhere on the board
GND: J3.2, J3.4, J3.6, J3.8, J3.10, RF1.1 (GND), RF1.2 (GND), RF1.3 (GND), RF2.1 (GND), RF2.2 (GND), RF2.3 (GND), RF3.1 (GND), RF3.2 (GND), RF3.3 (GND), RF4.1 (GND), RF4.2 (GND), RF4.3 (GND); also elsewhere on the board

Parts:
C1001_1, C1034_1, C1035_1: 100pF; GEN_C_0402; VOLTAGE RATING 50V; MANUFACTURER PART NUMBER GCM1555C1H101FA16D
C1002_1: 68pF; GEN_C_0402; VOLTAGE RATING 50V; MANUFACTURER PART NUMBER GCM1555C1H680FA16J
C1003_1, C1004_1, C1005_1, C1006_1, C1007_1, C1008_1, C1039_1, C1040_1: 10uF; GEN_C_0603; VOLTAGE RATING 25V; MANUFACTURER PART NUMBER GRM188R61E106MA73D
C1009_1, C1010_1, C1036_1, C1037_1, C1038_1, C1043_1, C1044_1, C1045_1, C1046_1, C1047_1, C1048_1, C1049_1, C1050_1, C1052_1, C1053_1, C1054_1, C1055_1, C1056_1, C1057_1: 1uF; GEN_C_0402; VOLTAGE RATING 25V; MANUFACTURER PART NUMBER GRM155R61E105KA12D
C1011_1, C1021_1, C1023_1: 3pF; GEN_C_0402; VOLTAGE RATING 200V; MANUFACTURER PART NUMBER CBR04C309B2GAC
C1012_1: 0.3pF; GEN_C_0402; VOLTAGE RATING 100V; MANUFACTURER PART NUMBER 04021J0R3ZBSTR
C1022_1: DNP; GEN_C_0603; not fitted
C1024_1: 1pF; GEN_C_0402; VOLTAGE RATING 50V; MANUFACTURER PART NUMBER CBR04C109A5GAC
C1025_1: 8pF; GEN_C_0402; VOLTAGE RATING 50V; MANUFACTURER PART NUMBER CBR04C809B5GAC
C1026_1, C1027_1, C1028_1, C1029_1: 22uF; GEN_C_0805; VOLTAGE RATING 25V; MANUFACTURER PART NUMBER GRM21BR61E226ME44L
C1030_1: 1nF; GEN_C_0603; VOLTAGE RATING 100V; MANUFACTURER PART NUMBER GCM1885C2A102FA16D
C1031_1: 10nF; GEN_C_0603; VOLTAGE RATING 50V; MANUFACTURER PART NUMBER GRM1885C1H103JA01J
C1032_1, C1033_1, C1041_1, C1042_1: 100nF; GEN_C_0402; VOLTAGE RATING 16V; MANUFACTURER PART NUMBER GCM155R71C104KA55D
C1058_1: 18pF; GEN_C_0402; VOLTAGE RATING 50V; MANUFACTURER PART NUMBER CBR04C180F5GAC
C1059_1: 2-6pF; EW_TRIMCAP; MANUFACTURER PART NUMBER SGC3S060
D1000_1, D1001_1: 1N4148WT-7; GEN_SOD_523; MANUFACTURER PART NUMBER 1N4148WT-7
FB1000_1, FB1001_1: 120@100MHZ; GEN_R_0402; MANUFACTURER PART NUMBER BLM15PX121SN1D
J1002_1: BNC; MOL_0731000105; MANUFACTURER PART NUMBER 73100-0105
K1000_1, K1001_1: G6K-2F-RF; KEMET_UD2-4.5NUN-L; MANUFACTURER PART NUMBER UD2-4.5NUN-L
Q1002_1, Q1003_1: DMN62D0UW; GEN_SOT_323; MANUFACTURER PART NUMBER DMN62D0UW-7
R52_1, R52_8, R97_1, R97_8, R1053_1: 0; GEN_R_0402; MANUFACTURER PART NUMBER RC0402JR-070RL
R1001_1, R1045_1, R1046_1: 1K; GEN_R_0402; TOLERANCE 1%; MANUFACTURER PART NUMBER RC0402FR-071KL
R1002_1, R1024_1: 976k; GEN_R_0402; TOLERANCE 1%; MANUFACTURER PART NUMBER RK73H1ETTP9763F
R1003_1, R1038_1: 10M; GEN_R_0603; TOLERANCE 1%; MANUFACTURER PART NUMBER RK73H1JTTD1005F
R1021_1: 15; GEN_R_0603; TOLERANCE 1%; MANUFACTURER PART NUMBER SG73P1JTTD15R0F
R1022_1, R1035_1: 30; GEN_R_0603; TOLERANCE 1%; MANUFACTURER PART NUMBER SG73P1JTTD30R0F
R1025_1: 49.9; GEN_R_0508; TOLERANCE 1%; POWER RATING 1W; MANUFACTURER PART NUMBER WK73R2ATTD49R9F
R1026_1: 20k; GEN_R_0402; TOLERANCE 1%; MANUFACTURER PART NUMBER RC0402FR-0720KL
R1027_1, R1028_1: 22; GEN_R_0603; TOLERANCE 1%; MANUFACTURER PART NUMBER SG73P1JTTD22R0F
R1029_1, R1030_1, R1031_1, R1032_1, R1033_1, R1044_1, R1052_1: 10K; GEN_R_0402; TOLERANCE 1%; MANUFACTURER PART NUMBER RC0402FR-0710KL
R1036_1: 35.7k; GEN_R_0402; TOLERANCE 1%; MANUFACTURER PART NUMBER RC0402FR-0735K7L
R1037_1: 49.9; GEN_R_0402; TOLERANCE 1%; MANUFACTURER PART NUMBER RC0402FR-0749R9L
R1039_1: 909k; GEN_R_0402; TOLERANCE 1%; MANUFACTURER PART NUMBER RC0402FR-07909KL
R1041_1, R1042_1, R1047_1: 90.9k; GEN_R_0402; TOLERANCE 1%; MANUFACTURER PART NUMBER RC0402FR-0790K9L
R1043_1: 2K; GEN_R_0402; TOLERANCE 1%; MANUFACTURER PART NUMBER RC0402FR-072KL
R1048_1: DNP; GEN_R_0402; TOLERANCE 1%; not fitted
R1049_1: 2K TRIMPOT; BOU_3mm_POT; TOLERANCE 1%; MANUFACTURER PART NUMBER TC33X-2-202E
SHLD1000_1: 2118727-2; MANUFACTURER PART NUMBER 2118727-2
SHLD1001_1: 2118728-2; TE_2118728-2; MANUFACTURER PART NUMBER 2118728-2
TP1014_1, TP1015_1, TP1016_1, TP1017_1, TP1018_1: PCB; GEN_TP_PCB
U1001_1: TMUX4053; TI_TSOT-23-16_DYY0016A; MANUFACTURER PART NUMBER TMUX4053DYYR
U1008_1: LMH6518; TI_WQFN_RGH0016A; MANUFACTURER PART NUMBER LMH6518SQX/NOPB
U1009_1: BUF802; TI_VQFN_RGT0016C; MANUFACTURER PART NUMBER BUF802IRGTR
U1011_1: OPA140AIDBVR; GEN_SOT23_5_950_2900X1600X1450; MANUFACTURER PART NUMBER OPA140AIDBVR

Connections:
+3V3_PGA: C1043_1.1, R1033_1.1, U1008_1.12 (VDD); also elsewhere on the board
+5V: C1004_1.2, C1006_1.2, C1008_1.2, C1040_1.2, C1044_1.1, C1045_1.1, C1046_1.1, C1047_1.1, C1048_1.1, C1049_1.1, C1050_1.1, FB1000_1.2, U1001_1.16 (VDD), U1009_1.1 (Vs+), U1009_1.12 (Vso+), U1009_1.15 (CLH), U1011_1.5 (V+); also elsewhere on the board
+VBIAS: C1033_1.2, R1045_1.1, R1046_1.1; also elsewhere on the board
+VUSB: C1026_1.2, C1028_1.2, R1027_1.1, R1028_1.1; also elsewhere on the board
-5V: C1003_1.1, C1005_1.1, C1007_1.1, C1052_1.2, C1053_1.2, C1054_1.2, C1055_1.2, C1056_1.2, C1057_1.2, R1036_1.2, U1001_1.7 (VSS), U1009_1.5 (Vs-), U1009_1.6 (Aux_Bias), U1009_1.8 (Vs-), U1009_1.10 (Vso-), U1011_1.2 (V-); also elsewhere on the board
-VBIAS: C1032_1.2, R1042_1.1; also elsewhere on the board
/ATTEN_1: R1030_1.2, R1032_1.1, TP1015_1.1 (1_1); also elsewhere on the board
/CH1/+VPGA: C1036_1.1, C1037_1.1, C1038_1.1, C1039_1.2, FB1000_1.1, U1008_1.3 (VCC), U1008_1.4 (VCC)
/CH1/ATTEN_1X: K1001_1.4, K1001_1.5
/CH1/ATTEN_50X_IN: C1012_1.2, C1023_1.2, K1001_1.2, R1001_1.2, R1024_1.1
/CH1/ATTEN_50X_OUT: C1021_1.2, C1024_1.1, C1059_1.1, K1001_1.7, R1024_1.2, R1026_1.2
/CH1/ATTEN_IN: K1000_1.6, K1001_1.3
/CH1/ATTEN_OUT: K1001_1.6, R1035_1.1, R1039_1.1
/CH1/ATTEN_OUT_R: C1030_1.2, R1035_1.2
/CH1/AUX_R_N: R97_8.1, U1008_1.2 (AUX_N)
/CH1/AUX_R_P: R52_8.1, U1008_1.1 (AUX_P)
/CH1/BNC_IN: J1002_1.1 (Signal), K1000_1.3
/CH1/BUF_IN: C1030_1.1, R1038_1.2, U1009_1.2 (IN)
/CH1/BUF_IN_AUX: C1034_1.2, R1043_1.1, U1009_1.4 (IN_Aux)
/CH1/BUF_IN_BIAS: R1038_1.1, U1009_1.3 (IN_Bias)
/CH1/BUF_OUT: R1037_1.1, R1041_1.1, U1009_1.11 (OUT)
/CH1/BUF_OUT_R: R1037_1.2, U1008_1.6 (IN_P)
/CH1/BUF_R_BIAS: R1036_1.1, U1009_1.7 (R_Bias)
/CH1/DC_FB: C1035_1.2, R1041_1.2, R1042_1.2, R1044_1.1, U1001_1.15 (D2), U1011_1.4 (-)
/CH1/DC_FB_TRIM: R1044_1.2, R1048_1.2, R1049_1.1, R1049_1.2
/CH1/OPA_OUT: C1035_1.1, R1043_1.2, U1001_1.4 (D3), U1011_1.1 (OUT)
/CH1/OUT_R_N: R97_1.1, U1008_1.14 (OUT_N)
/CH1/OUT_R_P: R52_1.1, U1008_1.15 (OUT_P)
/CH1/PGA_BIAS: C1042_1.2, FB1001_1.2, R1045_1.2, R1046_1.2, TP1017_1.1 (1_1), U1008_1.7 (IN_N)
/CH1/TERM_1M: K1000_1.2, R1022_1.2
/CH1/TERM_1M_R: C1022_1.2, K1000_1.7, R1022_1.1
/CH1/TERM_50Z: C1058_1.2, K1000_1.4, R1021_1.2, R1025_1.2
/CH1/TERM_50Z_R: K1000_1.5, R1021_1.1, R1053_1.2
/CH1_AUX_N: R97_8.2; also elsewhere on the board
/CH1_AUX_P: R52_8.2; also elsewhere on the board
/CH1_N: R97_1.2; also elsewhere on the board
/CH1_P: R52_1.2; also elsewhere on the board
/DC_CPL_1: R1052_1.1, TP1018_1.1 (1_1), U1001_1.9 (SEL3), U1001_1.10 (SEL2), U1001_1.11 (SEL1); also elsewhere on the board
/PGA_CSn_1: R1033_1.2, TP1016_1.1 (1_1), U1008_1.9 (CSn); also elsewhere on the board
/PGA_SCLK: U1008_1.11 (SCLK); also elsewhere on the board
/PGA_SDIO: U1008_1.10 (SDIO); also elsewhere on the board
/TERM_1: R1029_1.2, R1031_1.1, TP1014_1.1 (1_1); also elsewhere on the board
/TRIM_1: C1041_1.2, FB1001_1.1
/VCM: U1008_1.13 (VCM), U1008_1.16 (AUX_VCM)
GND: C1003_1.2, C1004_1.1, C1005_1.2, C1006_1.1, C1007_1.2, C1008_1.1, C1009_1.2, C1010_1.2, C1011_1.1, C1021_1.1, C1022_1.1, C1025_1.1, C1026_1.1, C1027_1.1, C1028_1.1, C1029_1.1, C1032_1.1, C1033_1.1, C1034_1.1, C1036_1.2, C1037_1.2, C1038_1.2, C1039_1.1, C1040_1.1, C1041_1.1, C1042_1.1, C1043_1.2, C1044_1.2, C1045_1.2, C1046_1.2, C1047_1.2, C1048_1.2, C1049_1.2, C1050_1.2, C1052_1.1, C1053_1.1, C1054_1.1, C1055_1.1, C1056_1.1, C1057_1.1, C1059_1.2, J1002_1.2 (SHIELD), Q1002_1.3 (S), Q1003_1.3 (S), R1003_1.2, R1025_1.1, R1026_1.1, R1031_1.2, R1032_1.2, R1047_1.2, R1048_1.1, R1049_1.3, R1052_1.2, SHLD1001_1.1 (1_1), U1001_1.6 (~EN), U1001_1.8 (GND), U1008_1.5 (GND), U1008_1.8 (GND), U1008_1.17 (PAD), U1009_1.14 (CLL), U1009_1.17 (PAD); also elsewhere on the board
unnamed: C1011_1.2, R1001_1.1
unnamed: C1012_1.1, R1002_1.1
unnamed: C1023_1.1, C1024_1.2, C1025_1.2, R1002_1.2
unnamed: C1058_1.1, R1053_1.1
unnamed: D1000_1.2 (A), K1000_1.8, Q1002_1.1 (D)
unnamed: C1009_1.1, C1027_1.2, D1000_1.1 (K), K1000_1.1, R1027_1.2
unnamed: D1001_1.2 (A), K1001_1.8, Q1003_1.1 (D)
unnamed: C1010_1.1, C1029_1.2, D1001_1.1 (K), K1001_1.1, R1028_1.2
unnamed: Q1002_1.2 (G), R1029_1.1
unnamed: Q1003_1.2 (G), R1030_1.1
unnamed: C1031_1.1, R1039_1.2, R1047_1.1, U1001_1.14 (D1)
unnamed: C1031_1.2, R1003_1.1, U1001_1.13 (S1B), U1011_1.3 (+)
unnamed: C1001_1.2, U1001_1.2 (S2A)
unnamed: C1002_1.2, U1001_1.1 (S2B)
unnamed: C1001_1.1, U1001_1.5 (S3A)
unnamed: C1002_1.1, U1001_1.3 (S3B)

Notes on the sheet:
Termination and Attenuation
Input Buffer and AC/DC Coupling
This cap is switched in during AC coupling
This cap is switched in during DC coupling
Max current for 35.7kOhm R_Bias: 24mA @ V+ and 24mA @ V-
100k R_Bias wil be lower: 17mA per rail was measured on the EVM
Max VDD current: 0.35mA
Max VCC current before configuration (AUX output on): 0.225A
Max VCC current after configuration turns off AUX output: 0.165A
Programmable Gain Amplifier
50x Attenuator

Board: 6 copper layers, 65.0 x 23.1 mm, 111 parts (41 on the bottom side), 61 nets.

Notices in the files:
README.md:
License: MIT
